* BUF — buffer a válvulas termiônicas (2 INV; 2 válvulas JAN-6418)
.subckt BUF A Y VDD GND
X1 A n VDD GND INV
X2 n Y VDD GND INV
.ends BUF
